# Keil uVision project Fire_F103C8.uvprojx, settings and files
target MPU (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MPU +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,MPU6050,EMPL_TARGET_STM32F1
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\Middlewares\driver\eMPL;..\..\Middlewares\eMPL-hal;..\..\Middlewares\driver\include;..\..\Middlewares\driver\stm32L;..\..\Middlewares\mllite;..\..\Middlewares\mpl;..\..\Middlewares\porting;..\RVMDK（uv4）
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group eMD
    ../../Middlewares/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../../Middlewares/driver/stm32L/: log_stm32.c
    ../../Middlewares/eMPL-hal/: eMPL_outputs.c
    ../../Middlewares/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ../../Middlewares/porting/: mpu6050_SL.c
    ../../Middlewares/mpl/: libmpllib.lib
  group USER
    ../../User/: main.c stm32f10x_it.c
    ../../User/Led/: bsp_led.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/mpu6050/: mpu6050.c
    ../../User/usart/: bsp_usart.c
    ../../User/iic/: bsp_hard_i2c.c bsp_soft_i2c.c
    ./: pwm.c pid.c usart.c
  group DOC
    ../../Doc/: readme.txt
